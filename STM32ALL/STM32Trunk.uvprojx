# Keil uVision project STM32Trunk.uvprojx, settings and files
target STM32Pro (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32Trunk +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c include: Code\Include\modules
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./Code/Src/: main.c
  group modules
    ./Code/Src/Modules/beep/: beep.c
    ./Code/Src/Modules/gui/: gui.c
    ./Code/Src/Modules/key/: key.c
    ./Code/Src/Modules/lcd/: lcd_driver.c
    ./Code/Src/Modules/led/: led.c
    ./Code/Src/Modules/nixieTube/: nixietube.c
    ./Code/Src/Modules/system/: system.c
    ./Code/Src/Modules/usart/: usart.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
